# IAR project s4051a_loader.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __ARM_CORTEX_MX__; DEBUG; STM32F40_41xxx; USE_STM324xG_EVAL; USE_STDPERIPH_DRIVER; HOST_MODE_ENABLED; IAR_ARM_CM4F; USE_USB_OTG_FS; STM32_IAP; EXT_FLASH; S4051A
  ICCARM.CCIncludePath2: inc; ..\..\..\Projects\STM32_IAP\inc; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc\; ..\..\..\Libraries\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\Libraries\FreeRTOS\Source\include; ..\..\..\Libraries\FreeRTOS\Source; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\Libraries\AMT_Drivers\EXT_FLASH; ..\..\..\Libraries\AMT_Drivers\HT68F30; ..\..\..\Utilities\Third_Party\efsl\inc; ..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\Utilities\mainstream_v1\stm32f411; ..\..\..\Utilities\mainstream_v1\stm32f411\it; ..\APP_SRC\Include; ..\APP_SRC
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S4051A_SMT.bin
  ILINK.IlinkOutputFile: s4051a_release.out
  ILINK.IlinkKeepSymbols: APPMAIN
  ILINK.IlinkIcfFile: ..\..\..\Utilities\mainstream_v1\stm32f411\icf\stm32f411xe_release.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Bootloader (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __ARM_CORTEX_MX__; DEBUG; STM32F40_41xxx; USE_STM324xG_EVAL; USE_STDPERIPH_DRIVER; HOST_MODE_ENABLED; IAR_ARM_CM4F; USE_USB_OTG_FS; STM32_IAP; S4051A; EXT_FLASH
  OBJCOPY.OOCOutputFile: S4051A_bootloader.bin
  ILINK.IlinkOutputFile: s4051a_loader.out
  ILINK.IlinkIcfFile: ..\..\..\Utilities\mainstream_v1\stm32f411\icf\stm32f411xe_bootloader.icf
  group Drivers/EXT_FLASH
    ../../../Libraries/AMT_Drivers/EXT_FLASH/: ext_flash_driver.c
  group F411_LagacyDriver
    ../../STM32_IAP/F411_LagacyDriver/: HT68F30.c HT68F30.h HT68F30_i2c.c HT68F30_i2c.h
  group FreeRTOS
    ../../../Libraries/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../Libraries/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../Libraries/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h startup_stm32f411xe.s
  group Platform
    ../../../Utilities/mainstream_v1/stm32f411/: BTHandler.c ButtonLowLevel.c CardLowLevel.c CardLowLevel_Platform.c EepromDriver.c GPIOLowLevel.c GPIOMiddleLevel.c I2C1LowLevel.c I2C2LowLevel.c IRLowLevel.c IRLowLevelDecoder.c SPILowLevel.c StorageDeviceDriver.c UART_LowLevel.c
  group Platform/CLK_CONF
    ../../../Utilities/mainstream_v1/stm32f411/clk_conf/: system_stm32f4xx.c
  group Platform/IT
    ../../../Utilities/mainstream_v1/stm32f411/it/: stm32f4xx_it.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Third_Party/efsl
    ../../../Utilities/Third_Party/efsl/src/: dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
  group Third_Party/fat_fs
    ../../../Utilities/Third_Party/fat_fs/src/: fattime.c ff.c
  group USB_Host/Class/MSC
    ../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_fs_interface.c usbh_msc_scsi.c
  group USB_Host/Core
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_Host/Driver
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group User
    ../../STM32_IAP/src/: command.c flash_layer.c main.c usb_bsp.c usbh_core.c usbh_usr.c
