# IAR project s4051a_app.ewp, settings and files
configuration app (ARM)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: S4051A; DEBUG; FREE_RTOS; STM32F40_41xxx; USE_STM324xG_EVAL; USE_STDPERIPH_DRIVER; __ARM_CORTEX_MX__; IAR_ARM_CM4F; USE_USB_OTG_FS; SYS_PARMS_SECTION
  ICCARM.CCIncludePath2: inc\; ..\App_SRC; ..\App_SRC\Include; ..\App_SRC\SERVICES; ..\App_SRC\SERVICES\USB_HD\inc; ..\App_SRC\SERVICES\USB_HD\src; ..\App_SRC\SERVICES\wavePlayer; ..\App_SRC\Managers; ..\App_SRC\Dispatchers; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc\; ..\..\..\Libraries\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\Libraries\FreeRTOS\Source\include; ..\..\..\Libraries\FreeRTOS\Source; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\Utilities\Third_Party\efsl\inc; ..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\Utilities\mainstream_v1\stm32f411; ..\..\..\Utilities\mainstream_v1\stm32f411\it; ..\..\..\Libraries\AMT_Drivers\EXT_FLASH; ..\..\..\Libraries\AMT_Drivers\TAS5727; ..\..\..\Libraries\AMT_Drivers\TAS5711; ..\..\..\Libraries\AMT_Drivers\TAS5707; ..\..\..\Libraries\AMT_Drivers\TAS5713; ..\..\..\Libraries\AMT_Drivers\CS49844; ..\..\..\Libraries\AMT_Drivers\CS8422; ..\..\..\Libraries\AMT_Drivers\CS5346; ..\..\..\Libraries\AMT_Drivers\OTI3368; ..\..\..\Libraries\AMT_Drivers\HT68F30; ..\..\..\Libraries\AMT_Drivers\BTM640; ..\..\..\Libraries\AMT_Drivers\sii953x\application; ..\..\..\Libraries\AMT_Drivers\sii953x\application\app_ipv; ..\..\..\Libraries\AMT_Drivers\sii953x\application\app_cbus; ..\..\..\Libraries\AMT_Drivers\sii953x\application\app_cdc; ..\..\..\Libraries\AMT_Drivers\sii953x\application\app_cec; ..\..\..\Libraries\AMT_Drivers\sii953x\application\app_arc; ..\..\..\Libraries\AMT_Drivers\sii953x\application\app_diag; ..\..\..\Libraries\AMT_Drivers\sii953x\application\app_msw; ..\..\..\Libraries\AMT_Drivers\sii953x\application\app_osd; ..\..\..\Libraries\AMT_Drivers\sii953x\component; ..\..\..\Libraries\AMT_Drivers\sii953x\component\tx; ..\..\..\Libraries\AMT_Drivers\sii953x\component\repeater_avr; ..\..\..\Libraries\AMT_Drivers\sii953x\component\video_tables; ..\..\..\Libraries\AMT_Drivers\sii953x\component\audio_rx; ..\..\..\Libraries\AMT_Drivers\sii953x\component\edid_tx; ..\..\..\Libraries\AMT_Drivers\sii953x\component\debugger_hdmigear; ..\..\..\Libraries\AMT_Drivers\sii953x\component\cbus; ..\..\..\Libraries\AMT_Drivers\sii953x\component\rtpi; ..\..\..\Libraries\AMT_Drivers\sii953x\component\cdc; ..\..\..\Libraries\AMT_Drivers\sii953x\component\cec_manager; ..\..\..\Libraries\AMT_Drivers\sii953x\component\thx; ..\..\..\Libraries\AMT_Drivers\sii953x\component\ipv; ..\..\..\Libraries\AMT_Drivers\sii953x\component\osd; ..\..\..\Libraries\AMT_Drivers\sii953x\component\cec_switch; ..\..\..\Libraries\AMT_Drivers\sii953x\component\cec_system_audio_control; ..\..\..\Libraries\AMT_Drivers\sii953x\driver; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\audio_mix_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\sii953x_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\cra_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\matrix_sw_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\nvram_sram_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\tpi_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\audio_rx_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\repeater_avr_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\gpio_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\tpg_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\cbus_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\cpi_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\arc_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\osd_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\driver\ipv_drv; ..\..\..\Libraries\AMT_Drivers\sii953x\platform\hal\ir_remote; ..\..\..\Libraries\AMT_Drivers\sii953x\platform\hal\eeprom; ..\..\..\Libraries\AMT_Drivers\sii953x\platform\hal\timer; ..\..\..\Libraries\AMT_Drivers\sii953x\platform\hal\i2c; ..\..\..\Libraries\AMT_Drivers\sii953x\platform\osal\timer; ..\..\..\Libraries\AMT_Drivers\sii953x\platform\board
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S4051A.bin
  ILINK.IlinkOutputFile: s4051c_app.out
  ILINK.IlinkIcfFile: ..\..\..\Utilities\mainstream_v1\stm32f411\icf\stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../APP_SRC/: App_main.c
  group APP/Dispatchers
    ../APP_SRC/Dispatchers/: ButtonCmdDispatcher.c NoiseGeneratorDispatcher.c UARTCmdDispatcher.c
  group APP/Managers
    ../APP_SRC/Managers/: AmplifierDeviceManager.c AudioDeviceManager.c AudioSystemHandler.c ChannelCheckManager.c CommandsManager.c FactoryCommandHandler.c IRCmdHandler.c PowerHandler.c RFHandler.c StorageDeviceManager.c SystemDefaultParams.c UIDeviceManager.c USBFileSearch.c USBMediaManager.c USBMusicManager.c
  group APP/SERVICES
    ../APP_SRC/SERVICES/: ButtonsDriver.c Debug.c HMI_Service.c VirtualTimer.c
  group APP/SERVICES/USB_HD
    ../APP_SRC/SERVICES/USB_HD/src/: usb_bsp.c usb_host_device.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c usbh_usr.c
  group Drivers/CS4953x
    ../../../Libraries/AMT_Drivers/cs4953x/: cs4953x.c cs4953x_spi.c
  group Drivers/CS49844
    ../../../Libraries/AMT_Drivers/CS49844/: cs49844.c cs49844_spi.c
  group Drivers/CS5346
    ../../../Libraries/AMT_Drivers/CS5346/: cs5346.c CS5346_i2c.c
  group Drivers/CS8422
    ../../../Libraries/AMT_Drivers/CS8422/: cs8422.c CS8422_i2c.c CS8422_ISR_Handler.c
  group Drivers/EXT_FLASH
    ../../../Libraries/AMT_Drivers/EXT_FLASH/: ext_flash_driver.c
  group Drivers/HT68F30
    ../../../Libraries/AMT_Drivers/HT68F30/: HT68F30.c HT68F30_i2c.c
  group Drivers/sii953x
    ../../../Libraries/AMT_Drivers/sii953x/: buildtime.c
    ../../../Libraries/AMT_Drivers/sii953x/component/audio_rx/: si_audio_component.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/hal/audio_dac/: si_audio_dac.c
    ../../../Libraries/AMT_Drivers/sii953x/component/cbus/: si_cbus_component.c si_cbus_rcp_parse.c
    ../../../Libraries/AMT_Drivers/sii953x/component/cdc/: si_cdc_component.c si_cdc_heac.c si_cdc_main.c
    ../../../Libraries/AMT_Drivers/sii953x/component/cec_manager/: si_cec_component.c si_cec_controller.c si_cec_rx.c si_cec_timer.c si_cec_tx.c
    ../../../Libraries/AMT_Drivers/sii953x/component/cec_switch/: si_cec_switch_api.c
    ../../../Libraries/AMT_Drivers/sii953x/component/repeater_avr/: si_connection_monitor.c si_repeater_component.c si_repeater_isr.c si_repeater_sha.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/cra_drv/: si_cra.c si_cra_cfg_template.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/sii953x_drv/: si_cra_cfg.c si_drv_3dgpio.c si_drv_sii953x.c
    ../../../Libraries/AMT_Drivers/sii953x/component/debugger_hdmigear/: si_debugger_hdmigear.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/arc_drv/: si_drv_arc.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/audio_rx_drv/: si_drv_audio.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/audio_mix_drv/: si_drv_audio_mix.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/cbus_drv/: si_drv_cbus.c si_drv_cbus_main.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/cpi_drv/: si_drv_cpi.c si_drv_cpi_regio.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/nvram_sram_drv/: si_drv_edid_rx.c si_drv_nvram_sram.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/gpio_drv/: si_drv_gpio.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/ipv_drv/: si_drv_ipv.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/matrix_sw_drv/: si_drv_msw.c si_drv_msw_hpd.c si_drv_msw_info.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/osd_drv/: si_drv_osd.c si_drv_osd_ram.c si_drv_osd_resource.c si_drv_osd_spi.c si_drv_osd_text.c si_drv_osd_tools.c si_drv_osd_window.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/repeater_avr_drv/: si_drv_repeater.c si_drv_repeater_sha.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/spi_drv/: si_drv_spi.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/tpg_drv/: si_drv_tpg.c
    ../../../Libraries/AMT_Drivers/sii953x/driver/tpi_drv/: si_drv_tpi_access.c si_drv_tpi_ddc_access.c si_drv_tpi_system.c
    ../../../Libraries/AMT_Drivers/sii953x/component/edid_tx/: si_edid_black_list.c si_edid_tx_analyzer.c si_edid_tx_component.c si_edid_tx_composer.c si_edid_tx_converter.c si_edid_tx_decode_h.c si_edid_tx_decode_l.c si_edid_tx_fmf.c si_edid_tx_scaler.c si_edid_tx_tables.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/hal/eeprom/: si_eeprom.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/hal/flash_update/: si_flash_update.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/hal/fpga/: si_fpga.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/board/: si_gpio.c si_platform.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/hal/i2c/: si_i2c.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/hal/idt5v9885t/: si_idt_5v9885t.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/hal/ir_remote/: si_infrared.c
    ../../../Libraries/AMT_Drivers/sii953x/component/ipv/: si_ipv_component.c si_ipv_data.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/hal/logger/: si_logger.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/osal/timer/: si_osal_timer.c
    ../../../Libraries/AMT_Drivers/sii953x/component/osd/: si_osd_component.c si_osd_handler.c si_osd_win_edit.c si_osd_win_listbox.c si_osd_win_menu.c si_osd_win_msgbox.c si_osd_win_slider.c si_osd_window.c
    ../../../Libraries/AMT_Drivers/sii953x/application/app_osd/: si_osd_resource.res.c sk_app_osd.c sk_app_osd_audio.c sk_app_osd_avr.c sk_app_osd_demo.c sk_app_osd_info.c sk_app_osd_lb_demo.c sk_app_osd_options.c sk_app_osd_portsel.c sk_app_osd_resource_data.c sk_app_osd_speaker.c sk_app_osd_video.c sk_app_osd_volume.c
    ../../../Libraries/AMT_Drivers/sii953x/component/rtpi/: si_rtpi_cbus.c si_rtpi_cec.c si_rtpi_component.c si_rtpi_default_reg.c si_rtpi_register_functions.c
    ../../../Libraries/AMT_Drivers/sii953x/component/cec_system_audio_control/: si_sac_main.c si_sac_msg.c
    ../../../Libraries/AMT_Drivers/sii953x/component/thx/: si_thx_component.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/hal/timer/: si_timer.c
    ../../../Libraries/AMT_Drivers/sii953x/component/tx/: si_tx_audio.c si_tx_avi.c si_tx_component.c si_tx_hdcp.c si_tx_info_frm.c si_tx_video.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/hal/serial/: si_uartstdio.c
    ../../../Libraries/AMT_Drivers/sii953x/platform/hal/usb/: si_usb_serial.c si_usb_serial_structs.c
    ../../../Libraries/AMT_Drivers/sii953x/component/video_tables/: si_video_tables.c
    ../../../Libraries/AMT_Drivers/sii953x/application/: sk953x_avr_repeater.c sk_app_audio_rx.c sk_app_btst.c sk_app_demo.c sk_app_device.c sk_app_edid.c sk_app_ediddata.c sk_app_gpio.c sk_app_infrared.c sk_app_repeater.c sk_app_setup.c sk_app_support.c sk_app_tv.c sk_app_tx.c startup_gcc.c
    ../../../Libraries/AMT_Drivers/sii953x/application/app_arc/: sk_app_arc.c sk_app_arc_demo.c
    ../../../Libraries/AMT_Drivers/sii953x/application/app_cbus/: sk_app_cbus.c sk_app_cbus_cec.c sk_app_cbus_demo.c sk_app_cbus_wake_sequence.c
    ../../../Libraries/AMT_Drivers/sii953x/application/app_cdc/: sk_app_cdc.c sk_app_cdc_demo.c
    ../../../Libraries/AMT_Drivers/sii953x/application/app_cec/: sk_app_cec.c sk_app_cec_demo.c sk_app_cec_logger.c
    ../../../Libraries/AMT_Drivers/sii953x/application/app_diag/: sk_app_diag.c
    ../../../Libraries/AMT_Drivers/sii953x/application/app_emu/: sk_app_emu_aud.c sk_app_emu_main.c sk_app_emu_osd.c sk_app_emu_spi.c
    ../../../Libraries/AMT_Drivers/sii953x/application/app_ipv/: sk_app_ipv.c sk_app_ipv_demo.c
    ../../../Libraries/AMT_Drivers/sii953x/application/app_msw/: sk_app_msw_demo.c sk_app_switch.c
    ../../../Libraries/AMT_Drivers/sii953x/application/app_thx/: sk_app_thx.c
  group Drivers/TAS5707
    ../../../Libraries/AMT_Drivers/TAS5707/: TAS5707.c TAS5707_i2c.c
  group Drivers/TAS5711
    ../../../Libraries/AMT_Drivers/TAS5711/: TAS5711.c TAS5711_i2c.c
  group Drivers/TAS5713
    ../../../Libraries/AMT_Drivers/TAS5713/: TAS5713.c TAS5713_i2c.c
  group Drivers/TAS5727
    ../../../Libraries/AMT_Drivers/TAS5727/: TAS5727.c TAS5727_i2c.c
  group FreeRTOS
    ../../../Libraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Libraries/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../Libraries/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s startup_stm32f411xe.s
  group Platform
    ../../../Utilities/mainstream_v1/stm32f411/: BTHandler.c ButtonLowLevel.c CardLowLevel.c CardLowLevel_Platform.c EepromDriver.c GPIOLowLevel.c GPIOMiddleLevel.c I2C1LowLevel.c I2C2LowLevel.c IRLowLevel.c IRLowLevelDecoder.c SPILowLevel.c StorageDeviceDriver.c UART_LowLevel.c
  group Platform/CLK_CONF
    ../../../Utilities/mainstream_v1/stm32f411/clk_conf/: system_stm32f4xx.c
  group Platform/IT
    ../../../Utilities/mainstream_v1/stm32f411/it/: stm32f4xx_it.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Third_Party/efsl
    ../../../Utilities/Third_Party/efsl/src/: dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
  group Third_Party/fat_fs
    ../../../Utilities/Third_Party/fat_fs/src/: fattime.c ff.c
  group USB_DUAL/USB_Device/Class/CDC
    ../../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_DUAL/USB_Device/Library
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB_DUAL/USB_Host/Class/MSC
    ../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_fs_interface.c usbh_msc_scsi.c
  group USB_DUAL/USB_Host/Library
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_OTG_Drviers
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
