<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\s4051a_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\s4051a_loader.ewp</path>
  </project>
  <batchBuild/>
</workspace>


