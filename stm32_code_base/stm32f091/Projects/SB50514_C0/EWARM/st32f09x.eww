<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Projects\SB50514_C0\sb50514_c0_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Projects\SB50514_C0\sb50514_c0_loader.ewp</path>
  </project>  
  <batchBuild/>
</workspace>


