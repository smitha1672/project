# IAR project sb50514_c0_app.ewp, settings and files
configuration app (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091CC ST STM32F091CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: FREE_RTOS; SB50514; MT8507_ITF; CS498xx_ITF; EXT_FLASH; EEPROM_512; VIRTUAL_TIMER_PROC; __ARM_CORTEX_MX__; USE_STDPERIPH_DRIVER; STM32F0XX; DEBUG; SYS_PARMS_SECTION; USE_STM320518_EVAL; STM320518_EVAL_REVB; EXT_FLASH_UPDATE
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\APP_SRC\inc; ..\..\..\APP_SRC\inc\Services; ..\..\..\App_SRC\src\Managers; ..\..\..\APP_SRC\AudioParameters\SB50514_C0; ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\..\Libraries\AMT_Drivers\MT8507; ..\..\..\..\..\Libraries\AMT_Drivers\CS498XX; ..\..\..\..\..\Libraries\AMT_Drivers\CS4953x; ..\..\..\..\..\Libraries\AMT_Drivers\EXT_FLASH; ..\..\..\..\..\Utilities\STM32F0xx_board; ..\..\..\..\..\Utilities\STM32F0-Discovery; ..\..\..\..\..\Utilities\STM32_EVAL\STM320518_EVAL; ..\..\..\..\..\Libraries\FreeRTOS\Source\include; ..\..\..\..\..\Libraries\FreeRTOS\Source\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SB50514.bin
  ILINK.IlinkOutputFile: SB50514_app.out
  ILINK.IlinkIcfFile: ..\..\stm32f09x_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../APP_SRC/src/: system_stm32f0xx.c
  group Drivers/CS4953x
    ../../../../../Libraries/AMT_Drivers/cs4953x/: cs4953x.c cs4953x_spi.c
  group EWARM
    ../../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group FreeRTOS
    ../../../../../Libraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../Libraries/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../../Libraries/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Managers
    ../../../APP_SRC/src/Managers/: AudioDeviceManager.c AudioSystemHandler.c
  group Services
    ../../../APP_SRC/src/Services/: Debug.c
  group StdPeriph_Driver
    ../../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group STM32F0xx_board
    ../../../../../Utilities/STM32F0xx_board/SB50514_C0/: STM32F0xx_SB50514_board.c
  group User
    ../../../APP_SRC/src/: main.c stm32f0xx_it.c
