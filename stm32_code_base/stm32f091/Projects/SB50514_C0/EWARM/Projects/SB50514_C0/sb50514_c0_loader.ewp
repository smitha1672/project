# IAR project sb50514_c0_loader.ewp, settings and files
configuration Bootloader (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091CC ST STM32F091CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32_IAP; USE_STDPERIPH_DRIVER; STM32F0XX; __ARM_CORTEX_MX__; USE_STM320518_EVAL; STM320518_EVAL_REVB; EXT_FLASH; SYS_PARMS_SECTION; SB50514; EXT_FLASH_UPDATE_MCU
  ICCARM.CCIncludePath2: ..\; ..\..\inc; ..\..\..\..\STM32F0xx_IAP\inc; ..\..\..\..\..\Projects\SB50514_C0\APP_SRC\inc; ..\..\..\..\..\Libraries\AMT_Drivers\EXT_FLASH; ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\..\Utilities\STM32F0xx_board; ..\..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM320518_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SB50514_bootloader.bin
  ILINK.IlinkOutputFile: SB50514_loader.out
  ILINK.IlinkIcfFile: ..\..\stm32f09x_boorloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: SB50514_SMT.bin
  ILINK.IlinkOutputFile: SB50514_release.out
  ILINK.IlinkKeepSymbols: APPMAIN
  ILINK.IlinkIcfFile: ..\..\stm32f09x_release.icf
  group AMT_Driver/EXT_FLASH
    ../../../../../Libraries/AMT_Drivers/EXT_FLASH/: ext_flash_driver.c
  group CMSIS
    ../../../../STM32F0xx_IAP/src/: system_stm32f0xx.c
  group EWARM
    ../../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group Stdperiph_Driver
    ../../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group STM320518_EVAL
    ../../../../../Utilities/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c
    ../../../../../Utilities/STM32F0xx_board/SB50514_C0/: STM32F0xx_SB50514_boot_board.c
  group User
    ../../../../STM32F0xx_IAP/src/: common.c flash_if.c main.c menu.c stm32f0xx_it.c ymodem.c
