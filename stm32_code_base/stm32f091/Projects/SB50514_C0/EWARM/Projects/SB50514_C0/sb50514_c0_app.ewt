<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>app</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\APP_SRC\src\system_stm32f0xx.c</name>
    </file>
  </group>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Source\Templates\iar\startup_stm32f0xx.s</name>
    </file>
  </group>
  <group>
    <name>FreeRTOS</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\FreeRTOS\Source\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\FreeRTOS\Source\event_groups.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\FreeRTOS\Source\portable\MemMang\heap_2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\FreeRTOS\Source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\FreeRTOS\Source\portable\IAR\ARM_CM0\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\FreeRTOS\Source\portable\IAR\ARM_CM0\portasm.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\FreeRTOS\Source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\FreeRTOS\Source\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\FreeRTOS\Source\timers.c</name>
    </file>
  </group>
  <group>
    <name>Services</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\APP_SRC\src\Services\Debug.c</name>
    </file>
  </group>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>STM32F0xx_board</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Utilities\STM32F0xx_board\SB50514_C0\STM32F0xx_SB50514_board.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\APP_SRC\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\APP_SRC\src\stm32f0xx_it.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\..\Utilities\STM32F0-Discovery\stm32f0_discovery.c</name>
  </file>
</project>


