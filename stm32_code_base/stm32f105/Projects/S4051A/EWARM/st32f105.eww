<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\S4051A\s4051a_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\S4051A\s4051a_loader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\S4051B\s4051b_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\S4051B\s4051b_loader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\S3851E\s3851e_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\S3851E\s3851e_loader.ewp</path>
  </project>  
  <project>
    <path>$WS_DIR$\S3851F\s3851f_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\S3851F\s3851f_loader.ewp</path>
  </project>    
  <project>
    <path>$WS_DIR$\S4551A\s4551a_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\S4551A\s4551a_loader.ewp</path>
  </project>
  <batchBuild/>
</workspace>


