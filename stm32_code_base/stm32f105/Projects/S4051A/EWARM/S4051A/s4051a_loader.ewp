# IAR project s4051a_loader.ewp, settings and files
configuration Bootloader (ARM)
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32_IAP; USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL; HOST_MODE_ENABLED; __ARM_CORTEX_MX__; USE_USB_OTG_FS; EXT_FLASH; S4051A
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\..\Projects\STM32_IAP\inc; ..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc\; ..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\Libraries\AMT_Drivers\EXT_FLASH; ..\..\..\..\Utilities\Third_Party\efsl\inc; ..\..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\App_SRC; ..\..\..\App_SRC\Include\; ..\..\..\App_SRC\SERVICES\STM_32F10X; ..\..\..\..\Utilities\mainstream_v1\stm32f10x
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S4051A_boot.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: ..\stm32f10x_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S4051A_RELEASE (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32_IAP; USE_STDPERIPH_DRIVER; STM32F10X_CL; __ARM_CORTEX_MX__; USE_STM3210C_EVAL; HOST_MODE_ENABLED; USE_USB_OTG_FS; EXT_FLASH; S4051A
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\..\Projects\STM32_IAP\inc; ..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc\; ..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\Libraries\AMT_Drivers\EXT_FLASH; ..\..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\Third_Party\efsl\inc; ..\..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\App_SRC; ..\..\..\App_SRC\Include\; ..\..\..\App_SRC\SERVICES\STM_32F10X; ..\..\..\..\Utilities\mainstream_v1\stm32f10x
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: S4051A_SMT.bin
  ILINK.IlinkOutputFile: S4051A_SMT.out
  ILINK.IlinkKeepSymbols: APPMAIN
  ILINK.IlinkIcfFile: ..\stm32f10x_release.icf
  group CMSIS
    ../../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../STM32_IAP/src/: system_stm32f10x.c
  group Drivers/EXT_FLASH
    ../../../../Libraries/AMT_Drivers/EXT_FLASH/: ext_flash_driver.c
  group EFSL
    ../../../../Utilities/Third_Party/efsl/src/: dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
  group FAT_FS
    ../../../../Utilities/Third_Party/fat_fs/src/: fattime.c ff.c
  group StartUp
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32_EVAL
    ../../../../Utilities/mainstream_v1/stm32f10x/: GPIOLowLevel.c GPIOMiddleLevel.c SPILowLevel.c
    ../../../../Utilities/STM32_EVAL/STM3210C_EVAL/: HT68F30.c HT68F30_i2c.c I2C1LowLevel.c stm3210c_eval.c
  group USB_Host/Class/MSC
    ../../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_fs_interface.c usbh_msc_scsi.c
  group USB_Host/Core
    ../../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_Host/Driver
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group User
    ../../../STM32_IAP/src/: command.c flash_layer.c main.c stm32f10x_it.c usb_bsp.c usbh_core.c usbh_usr.c
