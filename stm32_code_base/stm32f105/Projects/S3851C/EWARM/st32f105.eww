<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\S3851C\s3851c_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\S3851C\s3851c_loader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\S3851D\s3851d_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\S3851D\s3851d_loader.ewp</path>
  </project>
  <batchBuild/>
</workspace>


